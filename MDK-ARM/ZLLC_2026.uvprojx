# Keil uVision project ZLLC_2026.uvprojx, settings and files
target ZLLC_2026 (6240000::V6.24::ARMCLANG)
  device: STM32H723VGTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.0.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2401FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: ZLLC_2026 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=1
  c define: USE_HAL_DRIVER,STM32H723xx,__FPU_PRESENT=1,__FPU_USED=1,ARM_MATH_CM7,USE_PWR_LDO_SUPPLY
  c include: ../Core/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../User/Congfig/Inc;../User/Task/Inc;../User/Interaction/Inc;../User/Controller/Inc;../User/Device/Inc;../User/Driver/Inc;../User/Algorithm/Inc;../Drivers/CMSIS/Include;../DSP/Include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x50000
  group Config
    ../User/Congfig/Src/: config.cpp
  group Task
    ../User/Task/Src/: tsk_config_and_callback.cpp
  group Interaction
    ../User/Interaction/Src/: ita_controller.cpp ita_lcd_status.cpp
  group Controller
    ../User/Controller/Src/: ctl_manipulator.cpp
  group Device
    ../User/Device/Src/: dvc_dwt.cpp dvc_referee.cpp dvc_unitree_motor.cpp dvc_ak80_motor.cpp dvc_zdt_motor.cpp dvc_lcd.cpp
  group Driver
    ../User/Driver/Src/: drv_adc.cpp drv_bsp-boarda.cpp drv_can.cpp drv_dwt.cpp drv_i2c.cpp drv_math.cpp drv_spi.cpp drv_tim.cpp drv_uart.cpp
  group Algorithm
    ../User/Algorithm/Src/: alg_filter.cpp alg_fsm.cpp alg_pid.cpp alg_SMC_Control.cpp alg_slope.cpp alg_dynamics_mdh.cpp alg_dynamics_urdf.cpp alg_kinematics_mdh.cpp alg_kinematics_urdf.cpp
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dma.c fdcan.c iwdg.c spi.c tim.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_cortex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_iwdg.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Application/MDK-ARM
    ./: startup_stm32h723xx.s
software components: CMSIS:CORE 5.6.0, CMSIS:DSP 1.15.0
